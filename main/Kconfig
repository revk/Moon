## main/Kconfig
```kconfig
menu "Moon"
  
        config MOON
        string "Moon"
        default "moon.h"
        help
                The moon file

endmenu
```
